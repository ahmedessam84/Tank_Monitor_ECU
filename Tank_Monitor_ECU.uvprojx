# Keil uVision project Tank_Monitor_ECU.uvprojx, settings and files
target Tank_Monitor_ECU (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Tank_Monitor_ECU
  c flags: Optim=3 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: rvmdk PART_TM4C123GH6PM TARGET_IS_TM4C123_RB1
  c misc: --c99
  c include: D:\ti\TivaWare_C_Series-2.1.3.156\;D:\ti\TivaWare_C_Series-2.1.3.156\driverlib;D:\ti\TivaWare_C_Series-2.1.3.156\driverlib\rvmdk;D:\ti\TivaWare_C_Series-2.1.3.156\third_party\FreeRTOS;D:\ti\TivaWare_C_Series-2.1.3.156\usblib;D:\ti\TivaWare_C_Series-2.1.3.156\utils;D:\ti\TivaWare_C_Series-2.1.3.156\third_party\FreeRTOS\Source;D:\ti\TivaWare_C_Series-2.1.3.156\third_party\FreeRTOS\Source\portable\MemMang;D:\ti\TivaWare_C_Series-2.1.3.156\third_party\FreeRTOS\Source\include\;..\Tank_Monitor_ECU;D:\ti\TivaWare_C_Series-2.1.3.156\third_party\FreeRTOS\Source\portable\RVDS\ARM_CM4F
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: Tank_Monitor_ECU.sct
  link misc: --entry Reset_Handler
  group Source
    ./: Tank_Monitor_ECU.c btn.c btnmr.c cancom.c delay.c LCD20x04.c lcdmr.c rtc.c startup_rvmdk.S buttonspoll_task.c
    D:/ti/TivaWare_C_Series-2.1.3.156/third_party/FreeRTOS/Source/: list.c queue.c tasks.c
    D:/ti/TivaWare_C_Series-2.1.3.156/third_party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
    D:/ti/TivaWare_C_Series-2.1.3.156/third_party/FreeRTOS/Source/portable/MemMang/: heap_2.c
    D:/ti/TivaWare_C_Series-2.1.3.156/utils/: uartstdio.c ustdlib.c
    D:/ti/TivaWare_C_Series-2.1.3.156/driverlib/: can.c
  group Inc
    ./: buttonspoll_task.h switch_task.h rtc.h priorities.h led_task.h lcdmr.h LCD20x04.h FreeRTOSConfig.h delay.h cancom.h btnmr.h btn.h apptypes.h
  group Driver Library
    D:/ti/TivaWare_C_Series-2.1.3.156/driverlib/rvmdk/: driverlib.lib
software components: CMSIS:CORE 5.0.0
